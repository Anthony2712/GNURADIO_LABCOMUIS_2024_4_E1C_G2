options:
  parameters:
    generate_options: qt_gui
    id: uis
    output_language: python
    title: modulador de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: amplitud de portadora
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {state: disabled}
- name: B
  id: variable_qtgui_range
  parameters:
    label: cambio de banda
    start: '1'
    step: '2'
    stop: '1'
    value: '1'
  states: {state: disabled}
- name: B
  id: variable_qtgui_range
  parameters:
    label: '# muestras por segundo'
    rangeType: int
    start: '1'
    step: '1'
    stop: '20'
    value: '10'
  states: {state: disabled}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia de portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 300e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: 1e3
  states: {state: disabled}
- name: k
  id: variable_qtgui_range
  parameters:
    label: 'habilita portadora '
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {state: disabled}
- name: ka
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '10'
    value: '1'
  states: {}
- name: n
  id: variable
  parameters:
    value: '2'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 781.25e3
  states: {}
- name: samp_rate_1
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: Ac_1
  id: parameter
  parameters:
    label: amplitud de portadora
    type: eng_float
    value: '1'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: int(math.pow(2,n))
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-(math.pow(2,n)-1)/2'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/math.pow(2,n)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ka
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: 'B '
    type: float
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcomu/Descargas/session52_quevedobzrp.wav
    repeat: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: ka
  id: parameter
  parameters:
    label: coeficiente ka
    type: eng_float
    value: '1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: int(samp_rate)
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_repeat_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
